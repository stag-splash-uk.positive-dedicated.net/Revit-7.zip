Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Номер проекта
Time: 2020-02-03T17:48:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160314_0715(x64) - Exporter 16.0.1124.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 03 17:48:48 2020 * Host: DESKTOP-EUP4DR4 * Database: C:\Users\����\AppData\Local\Temp\{5DBE45EF-3560-473F-85EC-BE49F71A975A}\ifc * Database version: 5507 * Database creation date: Mon Feb 03 17:48:47 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 03 17:48:47 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 03 17:48:47 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: Статус проекта

# IfcSite, Default
RefLatitude: 55, 45, 25, 90026; RefLongitude: 37, 36, 54, 74707; RefElevation: 0 mm
Прочее - Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Категория: Сведения о проекте; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Прочее - Категория: Сведения о проекте; Адрес проекта: Укажите адрес; Дата утверждения проекта: Дата выпуска; Заказчик: Владелец; Наименование проекта: Наименование проекта; Номер проекта: Номер проекта; Статус проекта: Статус проекта

# IfcBuildingStorey, Уровень 1
LongName: Уровень 1; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Верхний брус 8 мм; Семейство: Уровень: Верхний брус 8 мм; Семейство и типоразмер: Уровень: Верхний брус 8 мм; Тип: Уровень: Верхний брус 8 мм
Идентификация - Имя типа: Верхний брус 8 мм; Имя: Уровень 1; Несущие конструкции: no; Построение этажа: yes
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: Заголовок уровня - Окружность: Заголовок уровня - Окружность; Образец линий: Центр; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: no; Цвет: 0

# IfcBuildingElementProxy: L-R99CS, Behind_the_Mirror-Paper_Towel_Dispenser-LOVAIR-Flat:L-R99CS:260338
In: Уровень 1
Type - Classification: C1030200 Bath & Toilet Accessories (Uniformat); Material: Steel-Lovair-Satin
Type - Зависимости - Отметка по умолчанию: 0 mm
Type - Идентификация - _distributed by: www.bimstore.co.uk; DocumentationInstallationGuide: www.lovair.com; DocumentationLiterature: www.lovair.com; DocumentationMaintenance: www.lovair.com; DocumentationTechnical: www.lovair.com; Product Documentation Link: www.lovair.com; Product O&M Link: www.lovair.com; Product Page Link: http://lovair.com/en/behind-the-mirror/L-R99; Product Specification Link: www.lovair.com; URL: http://lovair.com/en/behind-the-mirror/L-R99; Группа модели: L-R99; Заголовок OmniClass: Paper Towel Dispensers, Disposal Units; Изготовитель: Lovair Limited; Имя типа: L-R99CS; Ключевая пометка: N13/320; Код по классификатору: C1030200; Комментарии к типоразмеру: Satin finish; Номер OmniClass: 23.40.20.21.17; Описание: The L-R99 is a flat bottom behind the mirror paper towel dispenser which is loaded through the base and has a 600-800 paper towel capacity.; Описание по классификатору: Bath & Toilet Accessories
Type - Прочее - Категория: Специальное оборудование; _BIMspec_GUID: 0; _current revision: 1; Mtrl_bimspec_guid: 0; Mtrl_current revision: 0; Mtrl_ExpectedLife: 0; Mtrl_ReplacementCost: 0; Mtrl_SerialNumber: 0; Mtrl_TagNumber: 0; Mtrl_WarrantyDurationLabor: 0; Mtrl_WarrantyDurationParts: 0; Имя семейства: Behind_the_Mirror-Paper_Towel_Dispenser-LOVAIR-Flat
Type - Текст - _created by: www.lovair.com; AssetType: fixed; CreatedBy: www.lovair.com; CreatedOn: 'February 2015'; DurationUnit: Years; ExpectedLife: 2; Finish: Satin; Grade: 304; Material: Stainless Steel; Mtrl_Finish: Satin; Mtrl_Grade: 304; Mtrl_Material: Stainless Steel; NBSObjectName: Lovair L-R99 Paper Towel Dispenser; NBSReference: 45-35-72/344; TypeName: L-R99CS; Uniclass2: 45-35-72/344; WarrantyDescription: 2 years from date of purchase; WarrantyDurationParts: 12; WarrantyDurationUnit: months; WarrantyGuarantorParts: technical@lovair.com
Pset_BuildingElementProxyCommon - Reference: L-R99CS
Pset_ManufacturerTypeInformation - Manufacturer: Lovair Limited
Зависимости - Рабочая плоскость: <не связано>; Уровень: Уровень: Уровень 1
Прочее - Код типа: Behind_the_Mirror-Paper_Towel_Dispenser-LOVAIR-Flat: L-R99CS; Семейство: Behind_the_Mirror-Paper_Towel_Dispenser-LOVAIR-Flat: L-R99CS; Семейство и типоразмер: Behind_the_Mirror-Paper_Towel_Dispenser-LOVAIR-Flat: L-R99CS; Тип: Behind_the_Mirror-Paper_Towel_Dispenser-LOVAIR-Flat: L-R99CS; Уровень спецификации: Уровень: Уровень 1
Размеры - Объем: 0.0149401 m3; Площадь: 0.235642 m2
Стадии - Стадия возведения: Новая конструкция
